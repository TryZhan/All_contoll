# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSPM0G3507_Project (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "D:\ti_mpsm0\mspm0_sdk_2_01_00_03\tools\keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: D:\ti_mpsm0\mspm0_sdk_2_01_00_03\source\third_party\CMSIS\Core\Include;D:\ti_mpsm0\mspm0_sdk_2_01_00_03\source;..\BSP\PWM;..\..\All_contoll;..\..\..\All_contoll;..\BSP\Motor;..\BSP\Encoder;..\BSP\OLED;..\BSP\Line_Follow;..\BSP\UART
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: D:\ti_mpsm0\mspm0_sdk_2_01_00_03\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c
    ./: startup_mspm0g350x_uvision.s
  group BSP
    ../BSP/OLED/: oled.c
    ../BSP/PWM/: PWM.c
    ../BSP/Motor/: Motor.c Motor.h
    ../BSP/Encoder/: Encoder.c Encoder.h
    ../BSP/UART/: UART.c UART.h
    ../BSP/Control/: Contorl.c Control.h
    ../BSP/Line_Follow/: Line_Follow.c Line_Follow.h
  group Driverlib
    ../ti/: dl_vref.c dl_uart.c dl_trng.c dl_timer.c dl_spi.c dl_rtc_common.c dl_opa.c dl_mcan.c dl_mathacl.c dl_lfss.c dl_lcd.c dl_keystorectl.c dl_i2c.c dl_flashctl.c dl_dma.c dl_dac12.c dl_crcp.c dl_crc.c dl_common.c dl_aesadv.c dl_aes.c dl_adc12.c
